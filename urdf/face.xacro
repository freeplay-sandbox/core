Commit message: Replaced the 2 face_{0,1}.urdf by proper face.xacro

File: urdf/face.xacro (robot description, xacro)
@@ -1,4 +1,4 @@
-<robot name="face_0">
-  <link name="face_0">
+<robot name="$(arg name)">
+  <link name="$(arg name)">
     <visual>
         <geometry>
